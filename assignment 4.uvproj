# Keil uVision project assignment 4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2104 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: assignment 4
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: 1436508628_101__compact_R.h 1436508610_103__compact_coeff.h Startup.s task1.c
